# Repository hyiger/de10-lite-ram-rom

## KiCad design de10-lite-ram-rom.kicad_pcb

Parts:
C1, C2, C3: 100nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1, D2: GRN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: DE10-Lite GPIO; PinSocket_2x20_P2.54mm_Horizontal
R1, R2: 360R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R3, R4, R5: 10K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: AS6C4008A-55ZIN; TSOP-II-32_21.0x10.2mm_P1.27mm
U2: SST39SF040; PLCC-32_SMD-Socket
U3: 74LVC2G04; SOT-23-6_Handsoldering

Connections:
/A0: J1.1, U1.12, U2.12 (A0)
/A1: J1.2, U1.11, U2.11 (A1)
/A2: J1.3, U1.10, U2.10 (A2)
/A3: J1.4, U1.9, U2.9 (A3)
/A4: J1.5, U1.8, U2.8 (A4)
/A5: J1.6, U1.7, U2.7 (A5)
/A6: J1.7, U1.6, U2.6 (A6)
/A7: J1.8, U1.5, U2.5 (A7)
/A8: J1.9, U1.27, U2.27 (A8)
/A9: J1.10, U1.26, U2.26 (A9)
/A10: J1.13, U1.23, U2.23 (A10)
/A11: J1.14, U1.25, U2.25 (A11)
/A12: J1.15, U1.4, U2.4 (A12)
/A13: J1.16, U1.28, U2.28 (A13)
/A14: J1.17, U1.3, U2.29 (A14)
/A15: J1.18, U1.31, U2.3 (A15)
/A16: J1.19, U1.2, U2.2 (A16)
/A17: J1.20, U1.1, U2.30 (A17)
/A18: J1.21, U1.30, U2.1 (A18)
/D0: J1.31, U1.13, U2.13 (D0)
/D1: J1.32, U1.14, U2.14 (D1)
/D2: J1.33, U1.15, U2.15 (D2)
/D3: J1.34, U1.17, U2.17 (D3)
/D4: J1.35, U1.18, U2.18 (D4)
/D5: J1.36, U1.19, U2.19 (D5)
/D6: J1.37, U1.20, U2.20 (D6)
/D7: J1.38, U1.21, U2.21 (D7)
/RAM_~CE: J1.22, R4.2, U1.22, U3.3
/ROM_~CE: J1.23, R5.2, U2.22 (CE), U3.1
/~RD: J1.24, U1.24, U2.24 (OE)
/~WR: J1.26, R3.2, U1.29, U2.31 (PGM)
GND: C1.2, C2.2, C3.2, J1.12, J1.30, R1.1, R2.1, U1.16, U2.16 (GND), U3.2 (GND)
unnamed: D1.1 (K), R2.2
unnamed: D1.2 (A), U3.6
unnamed: D2.1 (K), R1.2
unnamed: D2.2 (A), U3.4
VCC: C1.1, C2.1, C3.1, J1.29, R3.1, R4.1, R5.1, U1.32, U2.32 (VCC), U3.5 (VCC)

Notes on the sheet:
512K SRAM
512K Flash

Board: 4 copper layers, 50.8 x 31.8 mm, 14 parts (8 on the bottom side), 37 nets.

## Commit log

2019-09-08 initial version
2019-09-09 fixed labels, tracks, created gerbers
2019-09-09 fanned out power traces
2019-09-09 version 1.0
2019-09-09 changed SRAM type
2019-09-11 moved some traces around
